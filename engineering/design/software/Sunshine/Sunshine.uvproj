# Keil uVision project Sunshine.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Sunshine +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 led_display_high_level_driver.c main.c stepper_high_level_driver.c timer_interrupt.c led_display_high_level_driver.h stepper_high_level_driver.h timer_interrupt.h power_manager.c power_manager.h
