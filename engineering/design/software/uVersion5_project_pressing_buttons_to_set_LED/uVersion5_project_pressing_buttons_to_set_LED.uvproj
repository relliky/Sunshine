# Keil uVision project uVersion5_project_pressing_buttons_to_set_LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: uVersion5_project_pressing_buttons_to_set_LED +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 pressing_buttons_to_set_LED.c
