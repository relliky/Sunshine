# Keil uVision project stepper.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: stepper +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c timer_interrupt.c timer_interrupt.h led_display_high_level_driver.c led_display_high_level_driver.h stepper_high_level_driver.c stepper_high_level_driver.h
