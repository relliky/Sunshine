# Keil uVision project DS18b20_uVersion5.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DS18b20_uVersion5 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 led_display_high_level_driver.c led_display_high_level_driver.h main.c timer_interrupt.c timer_interrupt.h
